Commit message: access teleop urdf change

File: access_teleop/files/model_files/urdf/cube_l.urdf (robot description, URDF)
Before this commit: robot cube_l, 1 links, 0 joints
Links:
- link cube_l__link: geometry collision box size=0.060 0.060 0.060; visual box size=0.060 0.060 0.060
